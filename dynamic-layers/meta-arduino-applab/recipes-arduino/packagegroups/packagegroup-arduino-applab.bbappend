# On Torizon OS, 'arduino' (UID 1000) is created next to 'torizon'
ARDUINO_APPLAB_USER_PROVIDER = "arduino-applab-torizon"
